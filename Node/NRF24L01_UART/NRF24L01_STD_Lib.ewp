# IAR project NRF24L01_STD_Lib.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; inc; src
  ICCSTM8.IccLang: 1
  ILINK.IlinkOutputFile: NRF24L01_STD_Lib.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: main.c nRF24L01.h RF24.cpp RF24.h stm8s_conf.h stm8s_it.c stm8s_it.h
  group inc
    inc/: stm8s.h stm8s_clk.h stm8s_gpio.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim2.h stm8s_uart1.h
  group src
    src/: stm8s_clk.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim2.c stm8s_uart1.c
